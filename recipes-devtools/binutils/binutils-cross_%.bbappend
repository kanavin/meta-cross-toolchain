BBCLASSEXTEND += "mcextendcross:arm-none-eabi"

PN:virtclass-mcextendcross-arm-none-eabi = "binutils-cross-${TARGET_SYS}"
TARGET_ARCH:virtclass-mcextendcross-arm-none-eabi = "arm"
TARGET_VENDOR:virtclass-mcextendcross-arm-none-eabi = "-none"
TARGET_OS:virtclass-mcextendcross-arm-none-eabi = "eabi"
PROVIDES:virtclass-mcextendcross-arm-none-eabi = ""
